# Keil uVision project membrane_keyboard.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: membrane_keyboard
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\Libraries\Mono_USBDevice_Driver\inc;..\..\..\Libraries\Mono_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\WB\mono;..\..\..\Libraries\CMSIS\Include;..\Keyboards\wk104_cs;..\Mono\GPIO;..\Mono\USB;..\..\Template;..\matrix;..\RTT;.
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Libraries/CMSIS/Device/WB/mono/startup/arm/: startup_mono.s
    ../../../Libraries/CMSIS/Device/WB/mono/: system_mono.c
  group User
    ./: main.c
  group Mono
    ../Mono/GPIO/: hal_pal_lld.c
    ../Mono/USB/: usbd_hid.c usbd_user.c usbd_user_desc.c usbd_user_hid.c
  group Quantum
    ../matrix/: matrix.c debonce.c timer.c keyprocess.c
    ./: task_usb.c task_app.c
  group StdPeriph_Driver
    ../../../Libraries/Mono_StdPeriph_Driver/src/: mono_crc.c mono_exti.c mono_flash.c mono_gpio.c mono_iwdg.c mono_rtc.c mono_spim.c
    ../../../Libraries/Mono_USBDevice_Driver/src/: usbd_core.c usbd_hw.c usbd_intr.c
  group FreeRTOS/Source
    ../../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Keyboads
    ../Keyboards/wk104_cs/: keymap.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
